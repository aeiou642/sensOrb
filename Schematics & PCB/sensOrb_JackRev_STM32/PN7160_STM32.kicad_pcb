# Repository aeiou642/sensOrb (continued)

## KiCad design Schematics & PCB/sensOrb/salp_board_round.kicad_pcb

Board: 4 copper layers, 56.2 x 56.2 mm, 63 parts (18 on the bottom side), 51 nets.

Parts:
BT1: Battery; BatteryHolder_Keystone_1060_1x2032
C1, C2: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C11: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6: 200p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8, C19, C22: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 220p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C18: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16: .1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21: 0.1 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23: 10 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: APFA3010; LED_Kingbright_APFA3010_3x1.5mm_Horizontal
D2: BZS55C5V1; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D3, D4: LED; LED_0805_2012Metric
D5: BAT54CW; SOT-323_SC-70
D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: Antenna; PinHeader_1x03_P2.54mm_Vertical
J3, J5: ATTINY3226; PinSocket_2x09_P2.54mm_Vertical
J4: POWER; PinSocket_2x03_P2.54mm_Vertical
J6: PinHeader_1x06_P2.54mm_Vertical
J7, J8: READ/WRITE; PinHeader_1x03_P2.54mm_Vertical
J9: COMM_SEL_1; PinHeader_1x03_P2.54mm_Vertical
J10: COMM_SEL_0; PinHeader_1x03_P2.54mm_Vertical
L1, L2: 560nH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1, Q2: DMN10H220L; SOT-23
R1, R8, R9, R11: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 2.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 560; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: PN5321A3HN/C106_55; QFN40G-0.5-6X6MM
U2: ATtiny3226-S; SOIC-20W_7.5x12.8mm_P1.27mm
U3: TP4057; TSOT-23-6
U4: LD1117S33TR; SOT-223-3_TabPin2
U5: DW01A; SOT-23-6
Y1: 27.12 MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C4.1, C8.1, C14.1, C19.2, C20.1, J4.4, U1.23 (PVDD), U1.40 (VBAT), U2.1 (VCC), U4.2 (VO)
+BAT: BT1.1 (+), C23.2, D5.1, R7.1, U3.3 (BAT)
/AVDD: C1.1, C2.1, C3.1, C7.1, C11.1, J9.3, J10.3, U1.5 (TVDD), U1.8 (AVDD), U1.39 (DVDD)
/I0: R11.2, U1.16 (I0)
/I1: R1.2, U1.17 (I1)
/M_SCL: J3.1, J3.2, J3.17, J3.18, J5.1, J5.2, J5.13, J5.14, J5.15, J5.16, U1.27 (NSS/P50_SCL/HSU_RX), U1.28 (MOSI/SDA/HSU_TX), U1.29 (MISO_/_P71), U2.2 (PA4), U2.10 (PB1), U2.11 (PB0), U2.17 (PA1), U2.18 (PA2)
/OSCIN: C15.1, U1.14 (OSCIN), Y1.1
/OSCOUT: C18.1, U1.15 (OSCOUT), Y1.3
/PA0: D2.2 (A), J5.11, J5.12, J7.3, U2.16 (~RESET/PA0)
/PA3: J5.17, J5.18, U1.30 (SCK/P72), U2.19 (PA3)
/PA5: J3.3, J3.4, U1.38 (RSTPD_N), U2.3 (PA5)
/PA6: J3.5, J3.6, U2.4 (PA6)
/PA7: J3.7, J3.8, U1.25 (P70_IRQ), U2.5 (PA7)
/PB2: J3.15, J3.16, J7.1, U2.9 (PB2)
/PB3: J3.13, J3.14, J8.1, U2.8 (PB3)
/PB4: J3.11, J3.12, U2.7 (PB4)
/PB5: J3.9, J3.10, U2.6 (PB5)
/PC0: J5.3, J5.4, U2.12 (PC0)
/PC1: J5.5, J5.6, R4.2, U2.13 (PC1)
/PC2: J5.7, J5.8, R5.2, U2.14 (PC2)
/PC3: J5.9, J5.10, R6.2, U2.15 (PC3)
/RX: C17.2, R3.2, U1.10 (RX)
/TX1: L2.2, U1.4 (TX1)
/TX2: L1.2, U1.6 (TX2)
/VMID: C16.1, R3.1, U1.9 (VMID)
/V_USB: D5.2, J6.4, R9.2, U3.4 (V_{CC})
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C18.2, C19.1, C20.2, C21.1, C22.2, C23.1, D1.2 (A), D6.1 (K), H1.1, H2.1, J1.2, J4.2, J4.3, J4.5, J4.6, J6.6, J9.1, J10.1, Q1.2 (S), Q2.2 (S), R8.1, R10.1, U1.1 (DVSS), U1.3 (TVSS1), U1.7 (TVSS2), U1.11 (AVSS), U1.18 (TESTEN), U1.41, U2.20 (GND), U3.2 (GND), U4.1 (GND), U5.6 (GND), Y1.2, Y1.4
unnamed: C10.2, C13.2, L2.1, R2.1
unnamed: C9.2, C12.1, L1.1
unnamed: C17.1, R2.2
unnamed: D1.4 (B), R4.1
unnamed: D1.3 (G), R5.1
unnamed: D1.1 (R), R6.1
unnamed: D2.1 (K), J8.3
unnamed: D3.2 (A), D4.2 (A), R9.1
unnamed: D3.1 (K), U3.1 (~CHRG)
unnamed: D4.1 (K), U3.5 (STDBY)
unnamed: D6.2 (A), R12.2
unnamed: C6.2, C10.1, J1.1
unnamed: C5.1, C9.1, J1.3
unnamed: J6.2, J7.2
unnamed: J6.3, J8.2
unnamed: J9.2, R1.1
unnamed: J10.2, R11.1
unnamed: Q1.3 (D), Q2.3 (D)
unnamed: Q1.1 (G), U5.1 (OD)
unnamed: Q2.1 (G), U5.3 (OC)
unnamed: R10.2, U3.6 (PROG)
unnamed: R8.2, U5.2 (CS)
unnamed: C21.2, R7.2, U5.5 (VCC)
VCC: C22.1, D5.3, J4.1, R12.1, U4.3 (VI)

## Code that names these connections

File Code/sensOrbPN7160/STM32PN7160/test/test_readNDEF/main.cpp (part):

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#include <stdlib.h>
#include <stdio.h>

#define PN7160_IRQ (PA4)
#define PN7160_VEN (PA5)
#define PN7160_ADDR (0x28)

// Function prototypes
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void displayDeviceInfo();
void displayRecordInfo(NdefRecord record);

Electroniccats_PN7150 nfc(PN7160_IRQ, PN7160_VEN, PN7160_ADDR, PN7160); // creates a global NFC device interface object, attached to pins 7 (IRQ) and 8 (VEN) and using the default I2C address 0x28,specify PN7150 or PN7160 in constructor
NdefMessage message;

uint8_t mode = 1;                                                  // modes: 1 = Reader/ Writer, 2 = Emulation, 3 = Peer to peer P2P

void setup() {
  Wire.setSDA(PB7);
  Wire.setSCL(PB6);
  Wire.begin();
  
  pinMode(PA13, OUTPUT);
  pinMode(PB15, OUTPUT);

  Serial.begin(115200);
  //while (!Serial);
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      Serial.println("Multiple cards are detected!");
    }
    Serial.println("Remove the Card");
    digitalWrite(PA13, HIGH);
    delay(2000);
    digitalWrite(PA13, LOW);
    nfc.waitForTagRemoval();
    Serial.println("Card removed!");
    Serial.println("Restarting...");
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
## Commit log

2025-02-27 Documentation added
    Added documentation for the BMI270, PN532 module, current board schematics (still a WIP), ATTiny3226
2025-02-27 file pathing
    fixed some pathing, added a custom folder for my very "creative" board that's still a WIP
2025-02-27 fixed README
2025-02-27 Ripped basic commands from elechouse driver, basic comments started
    Added some pretty basic comments from the usual manual on IF construction. A lot to go. It is 3:00 AM and I am taking a break.
2025-02-28 Update nfc.h
    - changed macro names
    - added some more comments
2025-03-01 Added wakeup function
2025-03-03 added reset, begin
    added some functions
2025-03-23 Significant Overhaul
    - was a bit too much work to write my own libraries, so implemented a few for now (with licenses) for now. will have to be optimized since the current memory usage is insanely high [3031/3072, 98.7% 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
2025-03-23 Edited initiator code
    Added an initiator and receiver file; also changing implementation to state machine implementation for debugging and purposes and also just easier implementation. For future design, static member fun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
2025-03-25 Started reciever code
    Most of the receiver code needs to be written first before this can be tested fully. Adding IMU data on too as "debug values". After optimizations, uses about 30% RAM and 40% flash.
2025-03-30 a lot of changes
2025-04-11 Added some stuff to the PN532
    - buffer reading and checking (need to change)
2025-04-14 Massive changes
2025-04-14 Real commits for real people
2025-04-23 Started PCB Layout
2025-04-23 Added some stuff
2025-04-25 Layout 1: No ERC/DRC done yet
2025-04-25 fixed repo
2025-04-29 Semi-finalized PCB design
2025-05-04 Board V1 - sent to fab (?)
2025-05-06 Flipped Battery Slot, Minor Edits
2025-05-13 Fixes To SCH, 4-Layer PCB In Progress
2025-05-16 Obtained pictures for SPS
2025-06-23 Updated Sch, Traces Routed, Needs Verification
2025-06-23 Fixed Silkscreen
2025-06-23 Fixes
2025-06-23 Updated Silkscreen Again
2025-06-26 Updated Tracewidths
2025-06-30 Antenna Fix + DRC Fixes
2025-06-30 Tracewidth Fixes
2025-06-30 Extra Tracewidth and DRC Fixes
2025-06-30 Minor DRC Fixes
2025-06-30 Minor Fixes
2025-07-01 Most Recent Version Before Fork
2025-07-01 Updated SCH
    Schematic update: new power regulator layout, communication protocol jumper selectors
2025-07-01 Extra Pin Net Labels
    Extra PN532 net labels for more communication protocols (HSU/I2C/SPI)
2025-07-01 PCB Layout Initializing
2025-07-01 PCB Progress
2025-07-01 PCB Design Progress
2025-07-01 PCB Layout Progress
2025-07-02 Routing Progress
2025-07-02 All Routed
    To do: Verify electrical connections(do they make sense), trace widths, DRC violations
2025-07-03 Various Tracewidth Adjustments, DRC Fixes
2025-07-03 Silkscreen Updates
2025-07-03 Silkscreen Updates
    Almost Done
2025-07-07 Functioning TX/RX
    Can't exactly send packets yet, but it can at least talk with the board now. Don't forget to setup platformIO and import this project. Modify the upload/monitor ports in the config file, or just manu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
2025-07-07 Silkscreen Fixes
2025-07-07 Placement/Clearance FIxes
2025-07-07 Routing Adjustments
2025-07-07 Added Photos
2025-07-08 Tracewidth Adjustments
2025-07-08 Generated Gerbers/Drills - Sent To Fab
2025-07-10 Fixes To Battery Management
2025-07-10 BOM Generated
2025-07-10 Functional tag R/W
    Use emulate tag to write to an NFC tag, read tag to dump mem contents. Modfied NDEF lib slightly
2025-07-10 forgot to remove some files
    done
2025-07-10 Added code
2025-07-22 New Code Dev
2025-07-24 IMU/Barometer Data Stream Working
2025-07-24 Basic Tag Read
2025-07-24 Included to Repository
2025-08-05 Code Dev
    To do: Get NDEF message formatted to send IMU/Baro data properly. Utilizing NDEFSendRawMessage as template.
2025-08-12 Documentation
2025-08-12 Code Updates
2025-10-21 NDEF Formatting of IMU+Baro Done
2026-01-20 Code Updates for Testing
    Working on fixing receive again
2026-02-26 Fixes to 7160 source config
2026-03-08 New PCB
2026-03-09 Setup
2026-03-10 Minor Changes
2026-03-25 Updates to STM32 design
2026-03-25 Added eval reference
2026-03-25 Revert "Added eval reference"
    This reverts commit 26ef526435c2ffd444c970b2d3daa2f7a7dbb942.
2026-03-25 Added old eval to copy over
2026-03-27 Baro unit design complete, core unit nearly done
2026-03-27 NFC/Core unit updates
    Only antenna design remaining
2026-03-28 Usb mount changed
2026-03-29 Schematic complete
2026-03-30 PCB Changes
2026-03-30 Layout preliminary complete
2026-03-31 Finalized PCB Layout
2026-04-01 Minor edits to layout
2026-04-06 Minor Barometer Changes
2026-04-07 Fixes to some footprints
2026-04-13 Output Files Made
2026-04-13 Image Reference Added
2026-05-12 Minor code staging
2026-05-12 Code file moves+PCB pngs
2026-05-14 Code fixes
2026-05-24 R/W Swap Fixes
2026-05-24 Header for read/write code
2026-06-01 IMU Sensor Datapacket Fixes
2026-06-02 RW Swap NDEF Payload Fixed
