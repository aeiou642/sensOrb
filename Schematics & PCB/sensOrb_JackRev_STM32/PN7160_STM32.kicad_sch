File: Schematics & PCB/sensOrb_JackRev_STM32/PN7160_STM32.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Setup
Parts:
- added U1: PN7160A1HN/C100E, footprints:QFN40_PN7160_NXP-M, symbol PN7160:PN7160A1HN_C100E
- added U2: STM32F411CEUx, Package_DFN_QFN:QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm, symbol MCU_ST_STM32F4:STM32F411CEUx
Connections:
- new net: U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U2.49 (VSS)
- no-connect marks 0 -> 5
Other:
- company: (none) -> Jack Cunningham
- title: (none) -> STM32-PN7160 SALP Integration

Commit message: Updates to STM32 design
Parts:
- added J1: USB_C_Receptacle_USB2.0_16P, symbol Connector:USB_C_Receptacle_USB2.0_16P
Connections:
- new net: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
- new net GND: J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD)
Other:
- moved on the sheet: U1, U2

Commit message: Baro unit design complete, core unit nearly done
Parts:
- removed U2: STM32F411CEUx, Package_DFN_QFN:QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm, symbol MCU_ST_STM32F4:STM32F411CEUx
- added BT1: Battery, Battery:BatteryHolder_Keystone_1060_1x2032, symbol Device:Battery
- added C1: 2.2u, symbol Device:C
- added C10: 1u, symbol Device:C
- added C11, C12, C6, C7, C8, C9: 0.1u, symbol Device:C
- added C13, C14: 4.7u, symbol Device:C
- added C15: 10 uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C16: 0.1 uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C17: 10nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C18: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added C2, C3: 1.5p, symbol Device:C
- added C4, C5: 10p, symbol Device:C
- added D1: RED LED, symbol Device:LED
- added D3, D4: LED, LED_SMD:LED_0805_2012Metric, symbol Device:LED
- added D5: BAT54CW, Package_TO_SOT_SMD:SOT-323_SC-70, symbol Diode:BAT54CW
- added H1, H2: MountingHole_Pad, MountingHole:MountingHole_2.2mm_M2_Pad, symbol Mechanical:MountingHole_Pad
- added J11, J3, J4, J7, J8, J9: Conn_01x04, Connector_JST:JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical, symbol Connector_Generic:Conn_01x04
- added J2: STM32 Optional I/O, Connector_PinSocket_2.54mm:PinSocket_2x09_P2.54mm_Vertical, symbol Connector_Generic:Conn_02x09_Top_Bottom
- added J5: IMU Top, Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
- added J6: IMU Bottom, Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
- added Q1, Q2: DMN10H220L, Package_TO_SOT_SMD:SOT-23, symbol Transistor_FET:DMN10H220L
- added R1, R2, R7: 5.1K, symbol Device:R
- added R10: 3.9k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- added R11: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- added R12, R9: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- added R13, R17, R18: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added R3: 2.2k, symbol Device:R
- added R4: 2,2k, symbol Device:R
- added R5, R8: 10k, symbol Device:R
- added R6: 10k NC, symbol Device:R
- added SW1: BOOT_SW, symbol Switch:SW_Push
- added SW2: RST_SW, symbol Switch:SW_Push
- added U2: TPS7A0508PDBZ, Package_TO_SOT_SMD:SOT-23, symbol Regulator_Linear:TPS7A0508PDBZ
- added U3: STM32F411CEU6, footprints:QFN50P700X700X60-49N, symbol STM32F411CEU6:STM32F411CEU6
- added U4: TP4057, Package_TO_SOT_SMD:TSOT-23-6, symbol Battery_Management:TP4057
- added U5: DW01A, Package_TO_SOT_SMD:SOT-23-6, symbol Battery_Management:DW01A
- added U6: TCA9548APWR, Package_SO:TSSOP-24_4.4x7.8mm_P0.65mm, symbol Interface_Expansion:TCA9548APWR
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Connections:
- net GND: now also BT1.2 (-), C1.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C16.1, C17.2, C18.2, C2.2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
- net +5V: now reaches J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
- net +5V: now also D5.2, J2.9 (Pin_9), R9.2, U4.4 (V_{CC})
- net at J1.A5 (CC1): now also R1.1
- net PA12: now reaches J1.A6 (D+)
- net PA12: now also J1.B6 (D+), U3.33 (PA12)
- net PA11: now reaches J1.A7 (D-)
- net PA11: now also J1.B7 (D-), U3.32 (PA11)
- net at J1.B5 (CC2): now also R2.1
- net VEN: now reaches U1.10 (VEN)
- net VEN: now also U3.14 (PA4)
- net SDA: now reaches U1.5 (I2C_SDA/SPI_MISO)
- net SDA: now also J6.5 (Pin_5), R18.2, R4.1, U3.43 (PB7), U6.23 (SDA)
- net SCL: now reaches U1.7 (I2C_SCL/SPI_SCK)
- net SCL: now also J6.4 (Pin_4), R17.2, R3.1, U3.42 (PB6), U6.22 (SCL)
- net IRQ: now reaches U1.8 (IRQ)
- net IRQ: now also U3.13 (PA3)
- new net: D4.1 (K), U4.5 (STDBY)
- new net: D3.2 (A), D4.2 (A), R9.1
- new net: C11.1, R5.2, SW1.2, U3.44 (BOOT0)
- new net: Q1.1 (G), U5.1 (OD)
- new net: Q1.3 (D), Q2.3 (D)
- new net: C1.1, U3.22 (VCAP_1)
- new net: C2.1, U3.3 (PC14-OSC32_IN), Y1.1
- new net: C3.2, U3.4 (PC15-OSC32_OUT), Y1.2
- new net: C4.1, U3.5 (PH0-OSC_IN), Y2.1
- new net: C5.2, U3.6 (PH1-OSC_OUT), Y2.3
- new net: C12.1, R6.1, SW2.1, U3.7 (NRST)
- new net: D1.2 (A), R7.1
- new net: Q2.1 (G), U5.3 (OC)
- new net: C16.2, R11.2, U5.5 (VCC)
- new net: D3.1 (K), U4.1 (~{CHRG})
- new net: R10.2, U4.6 (PROG)
- new net: R13.2, U6.3 (~{RESET})
- new net: R12.2, U5.2 (CS)
- new net +3.3V: C10.1, C13.2, C17.1, C18.1, C6.1, C7.1, C8.1, C9.1, J11.2 (Pin_2), J3.2 (Pin_2), J4.2 (Pin_2), J5.1 (Pin_1)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
- new net +BAT: BT1.1 (+), C15.2, D5.1, R11.1, U4.3 (BAT)
- new net IMU_INT: J6.6 (Pin_6), U3.45 (PB8)
- new net IMU_RST: J5.4 (Pin_4), U3.46 (PB9)
- new net PA0: J2.1 (Pin_1), U3.10 (PA0-WKUP)
- new net PA1: J2.2 (Pin_2), U3.11 (PA1)
- new net PA10: U3.31 (PA10)
- new net PA13: U3.34 (PA13)
- new net PA14: U3.37 (PA14)
- new net PA15: U3.38 (PA15)
- new net PA2: J2.3 (Pin_3), U3.12 (PA2)
- new net PA5: J2.4 (Pin_4), U3.15 (PA5)
- new net PA6: J2.5 (Pin_5), U3.16 (PA6)
- new net PA7: J2.6 (Pin_6), U3.17 (PA7)
- new net PA8: J2.7 (Pin_7), U3.29 (PA8)
- new net PA9: J2.8 (Pin_8), U3.30 (PA9)
- new net PB0: U3.18 (PB0)
- new net PB1: J2.11 (Pin_11), U3.19 (PB1)
- new net PB10: J2.15 (Pin_15), U3.21 (PB10)
- new net PB12: J2.16 (Pin_16), U3.25 (PB12)
- new net PB13: J2.17 (Pin_17), U3.26 (PB13)
- new net PB14: J2.18 (Pin_18), U3.27 (PB14)
- new net PB15: U3.28 (PB15)
- new net PB2: R8.2, U3.20 (PB2)
- new net PB3: J2.12 (Pin_12), U3.39 (PB3)
- new net PB4: J2.13 (Pin_13), U3.40 (PB4)
- new net PB5: J2.14 (Pin_14), U3.41 (PB5)
- new net SC0: J11.4 (Pin_4), U6.5 (SC0)
- new net SC1: J3.4 (Pin_4), U6.7 (SC1)
- new net SC2: J4.4 (Pin_4), U6.9 (SC2)
- new net SC3: J7.4 (Pin_4), U6.11 (SC3)
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Other:
- note added: "3v3 LDO"
- note added: "Battery Charger"
- note added: "Battery/Protection"
- note added: "I2C Mux For Barometer"
- note added: "IMU Mounting"
- note added: "Microcontroller"
- note added: "NFC"
- note added: "USB Connection"
- note added: "Voltage OR"
- moved on the sheet: J1, U1

Commit message: NFC/Core unit updates
Only antenna design remaining
Parts:
- removed BT1: Battery, Battery:BatteryHolder_Keystone_1060_1x2032, symbol Device:Battery
- removed D4: LED, LED_SMD:LED_0805_2012Metric, symbol Device:LED
- removed Q1, Q2: DMN10H220L, Package_TO_SOT_SMD:SOT-23, symbol Transistor_FET:DMN10H220L
- removed R10: 3.9k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- removed R11: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- removed R12, R9: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
- removed U2: TPS7A0508PDBZ, Package_TO_SOT_SMD:SOT-23, symbol Regulator_Linear:TPS7A0508PDBZ
- removed U4: TP4057, Package_TO_SOT_SMD:TSOT-23-6, symbol Battery_Management:TP4057
- removed U5: DW01A, Package_TO_SOT_SMD:SOT-23-6, symbol Battery_Management:DW01A
- added C19, C25: 0.1u, symbol Device:C
- added C20, C21, C22, C23: 2.2u, symbol Device:C
- added C24, C27: 4.7u, symbol Device:C
- added C26: 1u, symbol Device:C
- added C28, C29: 10p, symbol Device:C
- added D2: BLUE LED, symbol Device:LED
- added J10: Conn_01x02, Connector_JST:JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical, symbol Connector_Generic:Conn_01x02
- added L1: 4.7u, 500mA, symbol Device:L
- added R10: 200k, symbol Device:R
- added R11: 100, symbol Device:R
- added R12: 220, symbol Device:R
- added R14, R15: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added R9: 1.8M, symbol Device:R
- added U4: TLV75533PDBVR, DBV0005A_N, symbol TLV75533PDBVR:TLV75533PDBVR
- added U5: TPS61070DDCR, DDC0006A_N, symbol TPS61070DDCR:TPS61070DDCR
- added XTAL1: XRCGB27M120F3M00R0, footprints:XTAL_XRCGB27M120F3M00R0_MUR, symbol 27.12MHz_XRCGB27M120F3M00R0:XRCGB27M120F3M00R0
- C13, C14: value 4.7u -> 1u
- C15: value 10 uF -> 10u; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> (none)
- C16: value 0.1 uF -> 10u; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> (none)
- D3: value LED -> GREEN LED; footprint LED_SMD:LED_0805_2012Metric -> (none)
Connections:
- net +3.3V: now also U1.12 (VBAT2), U1.13 (VDD(UP)), U1.28 (VBAT), U1.6 (VDD(PAD)), C24.1, C25.1, C26.1, C27.1, U4.5 (OUT)
- net GND: now also D3.1 (K), U1.20 (VSS(TX)), U1.4 (VSS(PAD)), U1.41 (EPAD), U1.9 (VSS(A)), C19.2, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2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
- net IRQ: now also U3.14 (PA4); no longer U3.13 (PA3)
- net PA13: now also R12.2
- net PA14: now also U1.39 (WKUP_REQ)
- net PA15: now also U1.2 (DWL_REQ_2C_ADR1/SPI_MOSI)
- net PB15: now also R11.2
- net VCC: now also U4.1 (IN), U4.3 (EN)
- net VEN: now also U3.15 (PA5); no longer U3.14 (PA4)
- net at D3.2 (A): now also R12.1
- net BAT_IN: now reaches C16.2
- net BAT_IN: now also J10.1 (Pin_1), L1.1, U5.3 (EN), U5.6 (VBAT)
- net at U1.1 (I2C_ADR0/SPI_NSS): now also R15.2
- net TVDD: now reaches U1.14 (VDD(TX))
- net TVDD: now also U1.18 (TVDD_IN), U1.22 (TVDD_IN2), C20.2, C21.2
- net RXN: now reaches U1.15 (RXN)
- net RXP: now reaches U1.16 (RXP)
- net at U1.17 (VDD(VMID)): now also C19.1
- net TX2: now reaches U1.19 (TX2)
- net TX1: now reaches U1.21 (TX1)
- net VDD_INT: now reaches U1.26 (VDD(A))
- net VDD_INT: now also U1.27 (VDD), U1.31 (VDD(D)), C22.2, C23.2
- net XTAL2: now reaches U1.29 (XTAL2)
- net XTAL2: now also C28.1, XTAL1.3
- net at U1.3 (I2C_ADR1/SPI_MOSI): now also R14.2
- net XTAL1: now reaches U1.30 (NFC_CLK_XTAL1)
- net XTAL1: now also C29.1, XTAL1.1
- net +BAT renamed +BAT_OUT
- net +BAT_OUT: now also R9.2, U5.5 (VOUT)
- net PA5 renamed PA3
- net PA3: now also U3.13 (PA3); no longer U3.15 (PA5)
- new net: R10.2, R9.1, U5.4 (FB)
- new net: L1.2, U5.1 (SW)
- new net: D2.2 (A), R11.1
- no-connect marks 21 -> 25
Other:
- note added: "3.3V LDO"
- note added: "Battery/Boost Converter"
- note removed: "3v3 LDO"
- note removed: "Battery Charger"
- note removed: "Battery/Protection"
- moved on the sheet: C13, C14, D1, D5, R7, R8, U1

Commit message: Updates
Parts:
- added C30, C31: 1n, symbol Device:C
- added C32, C33: 327.1p, symbol Device:C
- added C34, C35: 85.2p, symbol Device:C
- added C36, C37: 151.8p, symbol Device:C
- added J12: Antenna_Conn, Connector_JST:JST_ACH_BM02B-ACHSS-GAN-ETF_1x02-1MP_P1.20mm_Vertical, symbol Connector_Generic:Conn_01x02
- added L2, L3: 160n, symbol Device:L
- added R16: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added R19, R22: 2.2k, symbol Device:R
- added R20, R21: 1.54, symbol Device:R
- U4: footprint DBV0005A_N -> footprints:DBV0005A_L
- U5: footprint DDC0006A_N -> footprints:DDC0006A_L
Connections:
- net GND: now also C32.1, C33.2, C36.1, C37.2, R16.1
- net PA15: now also R16.2
- net RXN: now also C30.1
- net RXP: now also C31.1
- net TX1: now also L3.1
- net TX2: now also L2.1
- new net: C34.1, C36.2, R20.1
- new net: C33.1, C35.1, L2.2, R22.1
- new net: C32.2, C34.2, L3.2, R19.2
- new net: C31.2, R19.1
- new net: C30.2, R22.2
- new net: C35.2, C37.1, R21.1
- new net TX1_IN: J12.1 (Pin_1), R20.2
- new net TX2_IN: J12.2 (Pin_2), R21.2
Other:
- moved on the sheet: C28, C29, XTAL1A

Commit message: Usb mount changed
Parts:
- removed J1: USB_C_Receptacle_USB2.0_16P, symbol Connector:USB_C_Receptacle_USB2.0_16P
- added J1: USB4215-03-A_REVA, footprints:GCT_USB4215-03-A_REVA, symbol USB4215-03-A_REVA:USB4215-03-A_REVA
- C1, C10, C11, C12, C13, C14, C15, C16, C19, C2, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C3, C4, C5, C6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: footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- D1, D2, D3: footprint (none) -> LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
- renumbered J2 to J11, J11 to J2, J7 to J5, J8 to J6, J9 to J7, J5 to J8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
Connections:
- net +5V: now also J1.A4_B9 (VBUS_A), J1.B4_A9 (VBUS_B)
- net GND: now also J1.A1_B12 (GND_A), J1.B1_A12 (GND_B), J1.SH1 (SHIELD), J1.SH2 (SHIELD__1), J1.SH3 (SHIELD__2), J1.SH4 (SHIELD__3)
- net PA11: now also J1.A7 (DN1), J1.B7 (DN2)
- net PA12: now also J1.A6 (DP1), J1.B6 (DP2)
- net at R1.1: now also J1.A5 (CC1)
- net at R2.1: now also J1.B5 (CC2)
Other:
- moved on the sheet: H1, H2, J8, J9, R1

Commit message: Schematic complete
Parts:
- removed R17, R18: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- removed R6: 10k NC, symbol Device:R
- removed SW1: BOOT_SW, symbol Switch:SW_Push
- removed SW2: RST_SW, symbol Switch:SW_Push
- added SW1, SW2: D6R90F2LFS, footprints:D6R90_CNK, symbol SPST-NO_D6R90F2LFS:D6R90F2LFS
- C30, C31: footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C32, C33: value 327.1p -> 330p; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C34, C35: value 85.2p -> 82p; footprint (none) -> Capacitor_SMD:C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
- C36, C37: value 151.8p -> 150p; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- L1: footprint (none) -> Inductor_SMD:L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
- L2, L3: footprint (none) -> Inductor_SMD:L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
- R1, R10, R2, R22, R5, R9: footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R11, R12, R20, R21: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R19: footprint (none) -> Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder
- R3: value 2.2k -> 4.7k; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R4: value 2,2k -> 4.7k; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R7: renamed from R8; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R8: renamed from R7; footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- Y1: footprint ABS07-32.768KHZ-T:XTAL_ABS07-32.768KHZ-T -> footprints:XTAL_ABS07-32.768KHZ-T
- Y2: footprint TSX-3225_24.0000MF20G-AC3:XTAL_TSX-3225_24.0000MF20G-AC3 -> footprints:XTAL_TSX-3225_24.0000MF20G-AC3
Connections:
- net +3.3V: now also SW1.1, SW1.4
- net GND: now also SW2.2, SW2.3
- net at C11.1, R5.2, U3.44 (BOOT0): now also SW1.2, SW1.3
- net at C12.1, U3.7 (NRST): now also SW2.1, SW2.4
Other:
- moved on the sheet: C11, C12, R5, R7
