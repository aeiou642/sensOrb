# Repository aeiou642/sensOrb

File README.md:

Jack's Test Branch for New PCB/Code Implementations

Steps for STM32 Development Setup With PlatformIO:

1. Install the PlatformIO IDE extension within VSCode
2. Using Zadig and having the board you want to program connected via USB, install drivers to use DFU programming
3. When creating a new PlatformIO project, enable the following flags in the platformio.ini file:
        
        [env:genericSTM32F411CE]
        platform = ststm32
        board = genericSTM32F411CE
        framework = arduino
        upload_protocol = dfu
        monitor_speed = 9600
        build_flags = 
	        -D ENABLE_USB_SERIAL
	        -D PIO_FRAMEWORK_ARDUINO_ENABLE_CDC
        lib_deps = 
            ....
            ....

Extra Important Notes:

 - When creating a new PlatformIO project, you should be able to select a specific version of STM32, make sure you select the board version you are using, and make sure it is provided in the platformio.ini file. I'm using a STM32F411CE, so that is why it is written in the env and board fields.

 - The monitor_speed parameter should be adjust to whatever monitor speed you wish to use and should match whatever speed you provide in Serial.begin(...).

 - If you want multiple monitors:
    Select the COM port you wish to monitor
    Go to the Terminal tab, click the drop down next to the plus on the right hand side (its near the running tasks window)
    Click 'Run Task' and then click the 'PlatformIO: Monitor' task that should have appeared at the top of the window

- If you want to add external libraries: click the PlatformIO extension button on the left, then click  libraries to search for what you want. Adding libraries should add the library's name in the lib_deps section in the platformio.ini file.

## KiCad design Schematics & PCB/sensOrb_JackRev_STM32/PN7160_STM32.kicad_pcb

Parts:
C1, C20, C21, C22, C23: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 1.5p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C28, C29: 10p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7, C8, C9, C11, C12, C19, C25: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C13, C14, C26: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C16: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C18: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24, C27: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C31: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C32, C33: 330p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C34, C35: 82p; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C36, C37: 150p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: RED LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: BLUE LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: GREEN LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: BAT54CW; SOT-323_SC-70
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: USB4215-03-A_REVA; GCT_USB4215-03-A_REVA; PARTREV A
J2, J3, J4, J5, J6, J7: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: IMU Top; PinSocket_1x06_P2.54mm_Vertical
J9: IMU Bottom; PinSocket_1x06_P2.54mm_Vertical
J10: Conn_01x02; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J11: STM32 Optional I/O; PinSocket_2x09_P2.54mm_Vertical
J12: Antenna_Conn; JST_ACH_BM02B-ACHSS-GAN-ETF_1x02-1MP_P1.20mm_Vertical
L1: 4.7u, 500mA; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
L2, L3: 160n; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1, R2, R8: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R7, R13, R14, R15, R16: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 1.8M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R22: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20, R21: 1.54; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_SPST; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: PN7160A1HN/C100E; QFN40_PN7160_NXP-M
U3: STM32F411CEU6; QFN50P700X700X60-49N; PARTREV 7
U4: TLV75533PDBVR; DBV0005A_L
U5: TPS61070DDCR; DDC0006A_L
U6: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
XTAL1: XRCGB27M120F3M00R0; XTAL_XRCGB27M120F3M00R0_MUR
Y1: ABS07-32.768KHZ-T; XTAL_ABS07-32.768KHZ-T; PARTREV 08.19.15
Y2: TSX-3225_24.0000MF20G-AC3; XTAL_TSX-3225_24.0000MF20G-AC3; PARTREV N/A

Connections:
+3.3V: C6.1, C7.1, C8.1, C9.1, C10.1, C13.2, C17.1, C18.1, C24.1, C25.1, C26.1, C27.1, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J9.1, J11.18, R3.2, R4.2, R8.2, R13.1, SW1.2 (B), U1.6 (VDD(PAD)), U1.12 (VBAT2), U1.13 (VDD(UP)), U1.28 (VBAT), U3.1 (VBAT), U3.9 (VREF+), U3.24 (VDD), U3.36 (VDD__1), U3.48 (VDD__2), U4.5 (OUT), U6.24 (VCC)
+5V: D5.2, J1.A4_B9 (VBUS_A), J1.B4_A9 (VBUS_B)
+BAT_OUT: C15.2, D5.1, R9.2, U5.5 (VOUT)
/BAT_IN: C16.2, J10.1, L1.1, U5.3 (EN), U5.6 (VBAT)
/BT: J8.1
/IMU_INT: J9.6, U3.45 (PB8)
/IMU_RST: J8.4, U3.46 (PB9)
/IRQ: U1.8 (IRQ), U3.14 (PA4)
/PA0: J11.1, U3.10 (PA0-WKUP)
/PA1: J11.3, U3.11 (PA1)
/PA2: J11.5, U3.12 (PA2)
/PA3: J11.7, U3.13 (PA3)
/PA6: J11.9, U3.16 (PA6)
/PA7: J11.11, U3.17 (PA7)
/PA8: J11.6, U3.29 (PA8)
/PA9: J11.8, U3.30 (PA9)
/PA10: U3.31 (PA10)
/PA11: J1.A7 (DN1), J1.B7 (DN2), U3.32 (PA11)
/PA12: J1.A6 (DP1), J1.B6 (DP2), U3.33 (PA12)
/PA13: R12.2, U3.34 (PA13)
/PA14: U1.39 (WKUP_REQ), U3.37 (PA14)
/PA15: R16.2, U1.2 (DWL_REQ_2C_ADR1/SPI_MOSI), U3.38 (PA15)
/PB0: U3.18 (PB0)
/PB1: J11.13, U3.19 (PB1)
/PB2: R7.2, U3.20 (PB2)
/PB3: J11.10, U3.39 (PB3)
/PB4: J11.12, U3.40 (PB4)
/PB5: J11.14, U3.41 (PB5)
/PB10: J11.15, U3.21 (PB10)
/PB12: J11.17, U3.25 (PB12)
/PB13: J11.2, U3.26 (PB13)
/PB14: J11.4, U3.27 (PB14)
/PB15: R11.2, U3.28 (PB15)
/RXN: C30.1, U1.15 (RXN)
/RXP: C31.1, U1.16 (RXP)
/SC0: J2.4, U6.5 (SC0)
/SC1: J3.4, U6.7 (SC1)
/SC2: J4.4, U6.9 (SC2)
/SC3: J5.4, U6.11 (SC3)
/SC4: J6.4, U6.14 (SC4)
/SC5: J7.4, U6.16 (SC5)
/SC6: U6.18 (SC6)
/SC7: U6.20 (SC7)
/SCL: J9.4, R3.1, U1.7 (I2C_SCL/SPI_SCK), U3.42 (PB6), U6.22 (SCL)
/SD0: J2.3, U6.4 (SD0)
/SD1: J3.3, U6.6 (SD1)
/SD2: J4.3, U6.8 (SD2)
/SD3: J5.3, U6.10 (SD3)
/SD4: J6.3, U6.13 (SD4)
/SD5: J7.3, U6.15 (SD5)
/SD6: U6.17 (SD6)
/SD7: U6.19 (SD7)
/SDA: J9.5, R4.1, U1.5 (I2C_SDA/SPI_MISO), U3.43 (PB7), U6.23 (SDA)
/TVDD: C20.2, C21.2, U1.14 (VDD(TX)), U1.18 (TVDD_IN), U1.22 (TVDD_IN2)
/TX1: L3.1, U1.21 (TX1)
/TX1_IN: J12.1, R20.2
/TX2: L2.1, U1.19 (TX2)
/TX2_IN: J12.2, R21.2
/VDD_INT: C22.2, C23.2, U1.26 (VDD(A)), U1.27 (VDD), U1.31 (VDD(D))
/VEN: U1.10 (VEN), U3.15 (PA5)
/XTAL1: C29.1, U1.30 (NFC_CLK_XTAL1), XTAL1.1
/XTAL2: C28.1, U1.29 (XTAL2), XTAL1.3
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C32.1, C33.2, C36.1, C37.2, D1.1 (K), D2.1 (K), D3.1 (K), H1.1, H2.1, J1.A1_B12 (GND_A), J1.B1_A12 (GND_B), J1.SH1 (SHIELD), J1.SH2 (SHIELD__1), J1.SH3 (SHIELD__2), J1.SH4 (SHIELD__3), J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.2, J8.3, J9.3, J10.2, J11.16, R1.2, R2.2, R5.1, R7.1, R10.1, R14.1, R15.1, R16.1, SW2.1 (A), U1.4 (VSS(PAD)), U1.9 (VSS(A)), U1.20 (VSS(TX)), U1.41 (EPAD), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS__1), U3.47 (VSS__2), U3.49 (VSS__3), U4.2 (GND), U5.2 (GND), U6.1 (A0), U6.2 (A1), U6.12 (GND), U6.21 (A2), Y2.2 (GND)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
unnamed: C30.2, R22.2
unnamed: C31.2, R19.1
unnamed: C32.2, C34.2, L3.2, R19.2
unnamed: C33.1, C35.1, L2.2, R22.1
unnamed: C34.1, C36.2, R20.1
unnamed: C35.2, C37.1, R21.1
unnamed: D1.2 (A), R8.1
unnamed: D2.2 (A), R11.1
unnamed: D3.2 (A), R12.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: C11.1, R5.2, SW1.1 (A), U3.44 (BOOT0)
unnamed: C12.1, SW2.2 (B), U3.7 (NRST)
unnamed: R15.2, U1.1 (I2C_ADR0/SPI_NSS)
unnamed: R14.2, U1.3 (I2C_ADR1/SPI_MOSI)
unnamed: C19.1, U1.17 (VDD(VMID))
unnamed: C2.1, U3.3 (PC14-OSC32_IN), Y1.1
unnamed: C3.2, U3.4 (PC15-OSC32_OUT), Y1.2
unnamed: C4.1, U3.5 (PH0-OSC_IN), Y2.1
unnamed: C5.2, U3.6 (PH1-OSC_OUT), Y2.3
unnamed: C1.1, U3.22 (VCAP_1)
unnamed: R9.1, R10.2, U5.4 (FB)
unnamed: L1.2, U5.1 (SW)
unnamed: R13.2, U6.3 (~RESET)
VCC: C14.2, D5.3, U4.1 (IN), U4.3 (EN)

Notes on the sheet:
Microcontroller
Battery/Boost Converter
I2C Mux For Barometer
USB Connection
Voltage OR
IMU Mounting
3.3V LDO
NFC

Board: 4 copper layers, 59.4 x 59.4 mm, 87 parts (27 on the bottom side), 81 nets.

## KiCad design Schematics & PCB/sensOrb_Baro_Unit/sensOrb_Baro_Unit.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J11: Conn_01x04; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical
R1, R2: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: MS583730BA01-50; QFN4_MS5637_TEC

Connections:
+3.3V: C1.1, J11.2, R1.1, R2.1, U1.2 (VDD)
/SC0: J11.4, R1.2, U1.3 (SCL)
/SD0: J11.3, R2.2, U1.4 (SDA)
GND: C1.2, H1.1, H2.1, J11.1, U1.1 (GND)

Board: 2 copper layers, 24.5 x 17.0 mm, 7 parts (4 on the bottom side), 4 nets.

## KiCad design Schematics & PCB/EVAL_Reference/Tactile-Sensor-Jack-Proto-V1.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C10, C12, C14, C16, C17: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C11: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
J1, J2: ATTINY3226; PinSocket_2x09_P2.54mm_Vertical
J3: PinHeader_1x06_P2.54mm_Horizontal
J4: UPDI; PinSocket_1x03_P2.54mm_Vertical
J5: IMU Top; PinSocket_1x06_P2.54mm_Vertical
J6: IMU Bottom; PinSocket_1x06_P2.54mm_Vertical
J7: POWER_JUMPER; PinHeader_1x03_P2.54mm_Vertical
J8: POWER; PinSocket_2x03_P2.54mm_Vertical
J9, J10, J11, J12: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J13: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U0: ATtiny3226-S; SOIC-20W_7.5x12.8mm_P1.27mm
U1: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U2, U3, U4, U5, U6, U7, U8, U9: MS5837-Sensors_Pressure_Underwater; MS5837-30B
U11: LD1117S33TR; SOT-223-3_TabPin2

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C16.1, C17.1, J4.1, J5.1, J5.2, J5.3, J6.1, J7.2, J8.5, J9.1, J10.1, J11.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, U0.1 (VCC), U1.24 (VCC), U2.2 (VDD), U3.2 (VDD), U4.2 (VDD), U5.2 (VDD), U6.2 (VDD), U7.2 (VDD), U8.2 (VDD), U9.2 (VDD)
/A0: J9.2, R20.1, U1.1 (A0)
/A1: J10.2, R21.1, U1.2 (A1)
/A2: J11.2, R22.1, U1.21 (A2)
/M_RESET: J12.2, J13.1, U1.3 (~RESET)
/M_SCL: J2.1, J2.2, R17.2, U0.11 (PB0), U1.22 (SCL)
/M_SDA: J1.17, J1.18, R18.2, U0.10 (PB1), U1.23 (SDA)
/PA0: J2.11, J2.12, J4.3, U0.16 (~RESET/PA0)
/PA1: J2.13, J2.14, U0.17 (PA1)
/PA2: J2.15, J2.16, J6.6, U0.18 (PA2)
/PA3: J2.17, J2.18, J5.6, U0.19 (PA3)
/PA4: J1.1, J1.2, U0.2 (PA4)
/PA5: J1.3, J1.4, U0.3 (PA5)
/PA6: J1.5, J1.6, U0.4 (PA6)
/PA7: J1.7, J1.8, U0.5 (PA7)
/PB2: J1.15, J1.16, J3.2, U0.9 (PB2)
/PB3: J1.13, J1.14, J3.3, U0.8 (PB3)
/PB4: J1.11, J1.12, U0.7 (PB4)
/PB5: J1.9, J1.10, U0.6 (PB5)
/PC0: J2.3, J2.4, J6.4, U0.12 (PC0)
/PC1: J2.5, J2.6, J6.5, U0.13 (PC1)
/PC2: J2.7, J2.8, J5.5, U0.14 (PC2)
/PC3: J2.9, J2.10, J5.4, U0.15 (PC3)
/SC0: R1.2, U1.5 (SC0), U2.3 (SCL)
/SC1: R3.2, U1.7 (SC1), U3.3 (SCL)
/SC2: R5.2, U1.9 (SC2), U4.3 (SCL)
/SC3: R7.2, U1.11 (SC3), U5.3 (SCL)
/SC4: R9.2, U1.14 (SC4), U6.3 (SCL)
/SC5: R11.2, U1.16 (SC5), U7.3 (SCL)
/SC6: R13.2, U1.18 (SC6), U8.3 (SCL)
/SC7: R15.2, U1.20 (SC7), U9.3 (SCL)
/SD0: R2.2, U1.4 (SD0), U2.4 (SDA)
/SD1: R4.2, U1.6 (SD1), U3.4 (SDA)
/SD2: R6.2, U1.8 (SD2), U4.4 (SDA)
/SD3: R8.2, U1.10 (SD3), U5.4 (SDA)
/SD4: R10.2, U1.13 (SD4), U6.4 (SDA)
/SD5: R12.2, U1.15 (SD5), U7.4 (SDA)
/SD6: R14.2, U1.17 (SD6), U8.4 (SDA)
/SD7: R16.2, U1.19 (SD7), U9.4 (SDA)
/V_REG: C15.1, J7.3, U11.2 (VO)
/V_USB: J3.4, J7.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J3.6, J4.2, J6.3, J8.2, J8.3, J8.4, J8.6, R20.2, R21.2, R22.2, U0.20 (GND), U1.12 (GND), U2.1 (GND), U3.1 (GND), U4.1 (GND), U5.1 (GND), U6.1 (GND), U7.1 (GND), U8.1 (GND), U9.1 (GND), U11.1 (GND)
unnamed: J12.1, R19.2
VCC: C14.1, J8.1, U11.3 (VI)

Notes on the sheet:
MCU
VRM
By default, jumper is left on to leave Reset high. If MCU Control over Reset is desired, the jumper can be removed in order to use the pin.
IMU Headers
I/O
Address pins for the Mux are default LOW. If address change is desired, jumpers can be placed on these pins.
Pressure Sensors
Reset Jumper-Pin
Mux Address Jumpers
Serial/FTDI Header
UPDI Header
Power Inputs
I2C Mux

Board: 4 copper layers, 60.5 x 99.0 mm, 67 parts (0 on the bottom side), 44 nets.

## KiCad design Schematics & PCB/sensOrb/salp_board.kicad_pcb

Board: 4 copper layers, 64.8 x 58.7 mm, 77 parts (0 on the bottom side), 51 nets.

Parts:
+BAT1: TestPoint; TestPoint_Pad_D1.0mm
BT1: Battery; BatteryHolder_Keystone_1060_1x2032
C1, C2: 200p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6: 220p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C10: .1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C14: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C22: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 10 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C18, C20, C21: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23: 0.1 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: BZS55C5V1; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D2, D3: LED; LED_0805_2012Metric
D4: BAT54CW; SOT-323_SC-70
D5: APFA3010; LED_Kingbright_APFA3010_3x1.5mm_Horizontal
DVDD1: TestPoint; TestPoint_Pad_D1.0mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
I0, I1: TestPoint; TestPoint_Pad_D1.0mm
J1, J8: ATTINY3226; PinSocket_2x09_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
J9: POWER_JUMPER; PinHeader_1x03_P2.54mm_Vertical
J10: POWER; PinSocket_2x03_P2.54mm_Vertical
J12: PinHeader_1x06_P2.54mm_Horizontal
L1, L2: 560nH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
PA1/MOSI/SDA/HSU_TX1, PA2/MISO/P71, PA3/SCK/P72, PA4/NSS/SCL/HSU_RX1, PA5/RSTPD_N1, PA7/IRQ1: TestPoint; TestPoint_Pad_D1.0mm
PC1, PC2, PC3: TestPoint; TestPoint_Pad_D1.0mm
Q1, Q2: IRLML6402; SOT-23
R1: 1.6K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R9, R10: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RX1: TestPoint; TestPoint_Pad_D1.0mm
SW2: SW_DPDT_x2; SW_CK_JS202011CQN_DPDT_Straight
TX1, TX2: TestPoint; TestPoint_Pad_D1.0mm
U1: LD1117S33TR; SOT-223-3_TabPin2
U2: PN5321A3HN/C106_55; QFN40G-0.5-6X6MM
U3: ATtiny3226-S; SOIC-20W_7.5x12.8mm_P1.27mm
U4: TP4057; TSOT-23-6
U6: DW01A; SOT-23-6
Y2: 27.12 MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C7.1, C8.1, C9.1, C14.1, C15.1, C20.1, DVDD1.1, I1.1, J9.2, J10.4, Q2.3 (D), U2.5 (TVDD), U2.8 (AVDD), U2.17 (I1), U2.39 (DVDD)
+BAT: +BAT1.1, BT1.1 (+), C17.2, D4.1, Q1.3 (D), R11.1, U2.40 (VBAT), U4.3 (BAT)
/M_SCL: J8.1, J8.2, U3.11 (PB0)
/M_SDA: J1.17, J1.18, U3.10 (PB1)
/OSCIN: C12.1, U2.14 (OSCIN), Y2.1
/OSCOUT: C13.1, U2.15 (OSCOUT), Y2.3
/PA0: D1.2 (A), J8.11, J8.12, SW2.3 (C), U3.16 (~RESET/PA0)
/PA1: J8.13, J8.14, PA1/MOSI/SDA/HSU_TX1.1, U2.28 (MOSI/SDA/HSU_TX), U3.17 (PA1)
/PA2: J8.15, J8.16, PA2/MISO/P71.1, U2.29 (MISO_/_P71), U3.18 (PA2)
/PA3: J8.17, J8.18, PA3/SCK/P72.1, U2.30 (SCK/P72), U3.19 (PA3)
/PA4: J1.1, J1.2, PA4/NSS/SCL/HSU_RX1.1, U2.27 (NSS/P50_SCL/HSU_RX), U3.2 (PA4)
/PA5: J1.3, J1.4, PA5/RSTPD_N1.1, U2.38 (RSTPD_N), U3.3 (PA5)
/PA6: J1.5, J1.6, U3.4 (PA6)
/PA7: J1.7, J1.8, PA7/IRQ1.1, U2.25 (P70_IRQ), U3.5 (PA7)
/PB2: J1.15, J1.16, SW2.1 (A), U3.9 (PB2)
/PB3: J1.13, J1.14, SW2.4 (A), U3.8 (PB3)
/PB4: J1.11, J1.12, U3.7 (PB4)
/PB5: J1.9, J1.10, U3.6 (PB5)
/PC0: J8.3, J8.4, U3.12 (PC0)
/PC1: J8.5, J8.6, PC1.1, R6.2, U3.13 (PC1)
/PC2: J8.7, J8.8, PC2.1, R7.2, U3.14 (PC2)
/PC3: J8.9, J8.10, PC3.1, R8.2, U3.15 (PC3)
/RX: C11.2, R2.2, RX1.1, U2.10 (RX)
/TX1: L1.2, TX1.1, U2.4 (TX1)
/TX2: L2.2, TX2.1, U2.6 (TX2)
/VMID: C10.1, R2.1, U2.9 (VMID)
/VOR: D4.3, J9.1
/V_REG: C22.1, J9.3, U1.2 (VO)
/V_USB: D4.2, J12.4, R4.2, U4.4 (V_{CC})
GND: BT1.2 (-), C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, D5.2 (A), J10.2, J10.3, J10.5, J10.6, J12.6, Q1.2 (S), Q2.2 (S), R5.1, R9.1, R10.1, U1.1 (GND), U2.1 (DVSS), U2.3 (TVSS1), U2.7 (TVSS2), U2.11 (AVSS), U2.18 (TESTEN), U2.41, U3.20 (GND), U4.2 (GND), U6.6 (GND), Y2.2, Y2.4
unnamed: C3.2, C5.1, L1.1
unnamed: C4.2, C6.2, L2.1, R1.1
unnamed: C11.1, R1.2
unnamed: D1.1 (K), R3.2
unnamed: D2.2 (A), D3.2 (A), R4.1
unnamed: D2.1 (K), U4.1 (~CHRG)
unnamed: D3.1 (K), U4.5 (STDBY)
unnamed: D5.4 (B), R6.1
unnamed: D5.3 (G), R7.1
unnamed: D5.1 (R), R8.1
unnamed: C1.1, C1.2, C2.1, C2.2, C3.1, C4.1, C5.2, C6.1, J4.1, J4.2, J4.3
unnamed: J12.2, SW2.2 (B)
unnamed: J12.3, SW2.5 (B)
unnamed: Q1.1 (G), U6.1 (OD)
unnamed: Q2.1 (G), U6.3 (OC)
unnamed: R3.1, SW2.6 (C)
unnamed: I0.1, R10.2, U2.16 (I0)
unnamed: R5.2, U4.6 (PROG)
unnamed: R9.2, U6.2 (CS)
unnamed: C23.2, R11.2, U6.5 (VCC)
VCC: C16.1, C18.1, C19.1, C21.1, J10.1, U1.3 (VI), U2.23 (PVDD), U3.1 (VCC)
